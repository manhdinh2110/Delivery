# Keil uVision project UGV_ARM.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UGV_ARM
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000
  c include: .\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Version2;.\CAN;.\SBUS;.\ENC;.\PWM;.\Timer;.\UART;.\UART_SONAR
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c utils.c
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group STM32F4xx
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group CAN
    ./CAN/: UGV_CAN.c
  group UART
    ./UART/: UGV_UART_JOYSTICK.c
  group Timer
    ./Timer/: UGV_Timer.c
  group PWM
    ./PWM/: UGV_PWM.c
  group ENC
    ./ENC/: UGV_ENC.c
  group SBUS
    ./SBUS/: UGV_SBUS.c
  group UART_SONAR
    ./UART_SONAR/: UGV_UART_SONAR.c
